# Keil uVision project teste_sdcc.uvproj, settings and files
target Target 1 (MCS-51)
  device: MSC1211Y5 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0x00-0x3FF) CLOCK(24000000) MODDP2
  output: teste_sdcc
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
