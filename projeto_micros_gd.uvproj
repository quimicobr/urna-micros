# Keil uVision project projeto_micros_gd.uvproj, settings and files
target Target 1 (MCS-51)
  device: MSC1211Y5 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0x00-0x3FF) CLOCK(24000000) MODDP2
  output: projeto_micros_gd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 codigo_main.c lcd.c teclado.c serial.c relogio.c myString.c buzzer.c buzzer.h
